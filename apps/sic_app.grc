options:
  parameters:
    author: Diego Badillo-San-Juan
    generate_options: qt_gui
    id: sic_app
    output_language: python
    title: SIC Simulation
  states: {}

blocks:
- name: amplitude_h
  id: variable_qtgui_range
  parameters:
    gui_hint: (5,0,1,1)
    label: Amplitude Multiplier
    start: '0'
    step: '0.2'
    stop: '4'
    value: '1'
    widget: eng_slider
  states: {}
- name: amplitude_l
  id: variable_qtgui_range
  parameters:
    gui_hint: (5,1,1,1)
    label: Amplitude Multiplier
    start: '0'
    step: '0.2'
    stop: '4'
    value: '0.5'
    widget: eng_slider
  states: {}
- name: ble_transmission_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (2,1,1,1)
    label: BLE Transmission Rate
    labels: '["1 Mbit/s", "2 Mbit/s"]'
    num_opts: '0'
    options: '[1000000, 2000000]'
    type: real
    value: '1000000'
  states: {}
- name: centre_frequency
  id: variable
  parameters:
    value: int(2495e6)
  states: {}
- name: delay_h
  id: variable_qtgui_range
  parameters:
    gui_hint: (4,0,1,1)
    label: Delay (µs)
    rangeType: int
    start: '0'
    step: '1'
    stop: int(800 * samp_rate * 1e-6)
    value: int(160 * samp_rate * 1e-6)
    widget: eng_slider
  states: {}
- name: delay_l
  id: variable_qtgui_range
  parameters:
    gui_hint: (4,1,1,1)
    label: Delay (µs)
    rangeType: int
    start: '0'
    step: '1'
    stop: int(800 * samp_rate * 1e-6)
    value: '0'
    widget: eng_slider
  states: {}
- name: label_802154
  id: variable_qtgui_label
  parameters:
    gui_hint: (1,0,1,1)
    label: <font size='5'><b>IEEE 802.15.4</b> (stronger signal) </font>
    type: string
    value: ''
  states: {}
- name: label_802154_tx_rate
  id: variable_qtgui_label
  parameters:
    gui_hint: (2,0,1,1)
    label: 'Transmission Rate: '
    type: string
    value: 250 kbit/s
  states: {}
- name: label_ble
  id: variable_qtgui_label
  parameters:
    gui_hint: (1,1,1,1)
    label: <font size='5'><b>BLE</b> (weaker signal) </font>
    type: string
    value: ''
  states: {}
- name: pause_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: (0,1,1,1)
    initPressed: 'False'
    label: Pause Periodic Transmission
    pressBackgroundColor: red
    pressed: '1'
    relBackgroundColor: red
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: payload_length_h
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,0,1,1)
    label: Payload Length (bytes)
    rangeType: int
    start: '1'
    step: '1'
    stop: '125'
    value: '10'
    widget: eng_slider
  states: {}
- name: payload_length_l
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,1,1,1)
    label: Payload Length (bytes)
    rangeType: int
    start: '1'
    step: '1'
    stop: '255'
    value: '140'
    widget: eng_slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: symbol_rate_high
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: trigger_delay
  id: variable
  parameters:
    value: 700e-6 *2
  states: {}
- name: ble_plot_sic_results_0
  id: ble_plot_sic_results
  parameters:
    max_queue_size: '10'
    sample_rate: samp_rate
  states: {state: disabled}
- name: ble_tag_iq_stream_0
  id: ble_tag_iq_stream
  parameters:
    sps: int(samp_rate / symbol_rate_high)
  states: {state: disabled}
- name: ble_tagged_iq_to_vector_0
  id: ble_tagged_iq_to_vector
  parameters:
    max_gap: 100000 * int(samp_rate / symbol_rate_high)
    post_offset: int(trigger_delay * samp_rate)
    pre_offset: int(trigger_delay * samp_rate)
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_l
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_h
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: centre_frequency
    samplerate: samp_rate
    type: fc32
    uri: 192.168.3.1
  states: {}
- name: iio_pluto_sink_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: centre_frequency
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'False'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: centre_frequency
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: '50'
    quadrature: 'True'
    rfdc: 'False'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (14,0,8,2)
    size: int(samp_rate/100)
    srate: samp_rate
    tr_delay: 800 * 1e-6
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"trigger"'
    type: complex
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Testing Tag IQ Stream block"'
    size: '16000'
    srate: samp_rate
    tr_delay: trigger_delay
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Payload start"'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Testing Tag IQ Stream block"'
    size: '160000'
    srate: samp_rate
    tr_delay: trigger_delay
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_tag: '"Payload start"'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    gui_hint: (6,0,8,2)
    int_max: '-50'
    int_min: '-60'
    type: complex
    update_time: '0.5'
    wintype: window.WIN_HANN
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    int_max: '0'
    int_min: '-80'
    type: complex
    update_time: '0.20'
  states: {state: disabled}
- name: sic_ble_hier_rx_0
  id: sic_ble_hier_rx
  parameters:
    base_address: '0x12345678'
    preamble_threshold: '0'
    sample_rate: samp_rate
    symbol_rate: ble_transmission_rate
  states: {state: disabled}
- name: sic_ble_packet_source_0_0
  id: sic_ble_packet_source
  parameters:
    base_address: '0x12345678'
    payload_length: payload_length_l
    sample_rate: samp_rate
    transmission_rate: ble_transmission_rate
  states: {}
- name: sic_ieee802154_hier_rx_0
  id: sic_ieee802154_hier_rx
  parameters:
    preamble_threshold: '5'
    sample_rate: samp_rate
    symbol_rate: 2e6
  states: {state: disabled}
- name: sic_ieee802154_packet_source_0
  id: sic_ieee802154_packet_source
  parameters:
    append_crc: 'True'
    payload_length: payload_length_h
    sample_rate: samp_rate
  states: {state: disabled}
- name: sic_periodic_message_source_0
  id: sic_periodic_message_source
  parameters:
    message: gr.pmt.mp("trigger")
    n_messages: '-1'
    period_ms: '2000'
  states: {}
- name: sic_successive_interference_cancellation_0
  id: sic_successive_interference_cancellation
  parameters:
    ble_transmission_rate: 1e6
    frequency_fine_window: '50'
    frequency_start: '-10000'
    frequency_step_coarse: '100'
    frequency_step_fine: '2'
    frequency_stop: '10000'
    max_queue_size: '10'
    protocol_high: '1'
    protocol_low: '0'
    sample_rate: samp_rate
    upsampling_factor: '2'
  states: {state: disabled}
- name: sic_transmission_enabler_0
  id: sic_transmission_enabler
  parameters:
    block_size: '1024'
  states: {}
- name: tx_trigger_button
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: (0,0,1,1)
    label: Trigger Transmission
    msgName: pressed
    relBackgroundColor: green
    type: int
    value: '1'
  states: {}

connections:
- [ble_tag_iq_stream_0, '0', ble_tagged_iq_to_vector_0, '0']
- [ble_tag_iq_stream_0, '0', qtgui_time_sink_x_0_0, '0']
- [ble_tagged_iq_to_vector_0, out, sic_successive_interference_cancellation_0, iq]
- [blocks_delay_0, '0', iio_pluto_sink_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0_0, '0', iio_pluto_sink_0_0, '0']
- [iio_pluto_source_0, '0', ble_tag_iq_stream_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_1, '0']
- [iio_pluto_source_0, '0', sic_ble_hier_rx_0, '0']
- [iio_pluto_source_0, '0', sic_ieee802154_hier_rx_0, '0']
- [pause_button, state, sic_periodic_message_source_0, pause]
- [sic_ble_hier_rx_0, '0', ble_tag_iq_stream_0, '1']
- [sic_ble_hier_rx_0, pdu, blocks_message_debug_0, print]
- [sic_ble_hier_rx_0, pdu, sic_successive_interference_cancellation_0, pdu]
- [sic_ble_packet_source_0_0, '0', blocks_delay_0, '0']
- [sic_ieee802154_hier_rx_0, '0', ble_tag_iq_stream_0, '1']
- [sic_ieee802154_hier_rx_0, pdu, blocks_message_debug_0, print]
- [sic_ieee802154_hier_rx_0, pdu, sic_successive_interference_cancellation_0, pdu]
- [sic_ieee802154_packet_source_0, '0', blocks_delay_0_0, '0']
- [sic_periodic_message_source_0, out, sic_transmission_enabler_0, trigger]
- [sic_successive_interference_cancellation_0, out, ble_plot_sic_results_0, in]
- [sic_transmission_enabler_0, '0', sic_ble_packet_source_0_0, '0']
- [sic_transmission_enabler_0, '0', sic_ieee802154_packet_source_0, '0']
- [tx_trigger_button, pressed, sic_transmission_enabler_0, trigger]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
