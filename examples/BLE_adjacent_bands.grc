options:
  parameters:
    generate_options: qt_gui
    id: BLE_adjacent_bands
    output_language: python
    title: BLE_adjacent_bands
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: int(250e3)
  states: {}
- name: plot_N
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: samples_per_bit
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tuning_LPF_cutoff_kHz
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,0
    start: '500'
    step: '1'
    stop: '2000'
    value: '1000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation)/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-50'
  states: {}
- name: ble_ble_packet_sink_0
  id: ble_ble_packet_sink
  parameters:
    base_address: '0x12345678'
    block_id: '0'
    lfsr: '0x1'
    preamble_threshold: '0'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/diego/Documents/SDR_projects/capture_nRF/data/new/BLE_BLE_2424MHz_2426MHz.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/400
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: samples_per_bit / 1E6
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samples_per_bit / decimation
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: tuning_LPF_cutoff_kHz*1000
    decim: decimation
    gain: '1'
    interp: '100'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/100
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 16,0
    label1: '"Quad Demodded"'
    label2: '"Sliced"'
    marker2: '0'
    name: '"Synced and downsampled"'
    nconnections: '2'
    size: int( plot_N/ samples_per_bit)
    srate: int(samp_rate / samples_per_bit)
    tr_chan: '1'
    tr_delay: '200E-6'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Payload length"'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 15,0
    label1: '"Quad Demodded"'
    name: '"Quad Demodded"'
    size: int( plot_N/ decimation)
    srate: int(samp_rate / decimation)
    type: float
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_1_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_simple_squelch_cc_0, '0', low_pass_filter_0_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_1, '0']
- [ble_ble_packet_sink_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [ble_ble_packet_sink_0, pmt, blocks_message_debug_0, print]
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_xx_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_1, '1']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_0, '0', ble_ble_packet_sink_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
