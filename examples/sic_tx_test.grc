options:
  parameters:
    author: diego
    generate_options: qt_gui
    id: sic_tx_test
    output_language: python
    title: sic_tx_test
  states: {}

blocks:
- name: ble_transmission_rate
  id: variable_qtgui_chooser
  parameters:
    label: BLE Transmission Rate
    labels: '["1 Mbit/s", "2 Mbit/s"]'
    num_opts: '0'
    options: '[1000000, 2000000]'
    type: real
    value: '1000000'
  states: {}
- name: pause_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    initPressed: 'False'
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: payload_length
  id: variable_qtgui_range
  parameters:
    label: Payload Length
    rangeType: int
    start: '1'
    step: '1'
    stop: '255'
    value: '50'
    widget: eng_slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/200
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: int(samp_rate/100)
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"trigger"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    int_max: '0'
    type: complex
  states: {}
- name: sic_ble_packet_source_0
  id: sic_ble_packet_source
  parameters:
    payload_length: payload_length
    sample_rate: 10e6
    transmission_rate: ble_transmission_rate
  states: {}
- name: sic_ble_packet_source_0_0
  id: sic_ble_packet_source
  parameters:
    payload_length: payload_length
    sample_rate: 10e6
    transmission_rate: '1000000'
  states: {state: disabled}
- name: sic_periodic_message_source_0
  id: sic_periodic_message_source
  parameters:
    message: gr.pmt.mp("trigger")
    n_messages: '-1'
    period_ms: '1000'
  states: {}
- name: sic_transmission_enabler_0
  id: sic_transmission_enabler
  parameters:
    block_size: '1024'
  states: {}
- name: tx_trigger_button
  id: variable_qtgui_msg_push_button
  parameters:
    msgName: pressed
    type: int
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_throttle2_0_1, '0', virtual_sink_0, '0']
- [pause_button, state, sic_periodic_message_source_0, pause]
- [sic_ble_packet_source_0, '0', blocks_add_xx_0, '0']
- [sic_ble_packet_source_0_0, '0', blocks_add_xx_0, '1']
- [sic_periodic_message_source_0, out, sic_transmission_enabler_0, trigger]
- [sic_transmission_enabler_0, '0', blocks_throttle2_0_1, '0']
- [tx_trigger_button, pressed, sic_transmission_enabler_0, trigger]
- [virtual_source_0, '0', sic_ble_packet_source_0, '0']
- [virtual_source_0, '0', sic_ble_packet_source_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
