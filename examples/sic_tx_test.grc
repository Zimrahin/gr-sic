options:
  parameters:
    author: diego
    generate_options: qt_gui
    id: sic_tx_test
    output_language: python
    title: sic_tx_test
  states: {}

blocks:
- name: amplitude_h
  id: variable_qtgui_range
  parameters:
    gui_hint: (5,0,1,1)
    label: Amplitude Multiplier
    start: '0'
    step: '0.2'
    stop: '4'
    value: '1'
    widget: eng_slider
  states: {}
- name: amplitude_l
  id: variable_qtgui_range
  parameters:
    gui_hint: (5,1,1,1)
    label: Amplitude Multiplier
    start: '0'
    step: '0.2'
    stop: '4'
    value: '1'
    widget: eng_slider
  states: {}
- name: ble_transmission_rate
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (2,1,1,1)
    label: BLE Transmission Rate
    labels: '["1 Mbit/s", "2 Mbit/s"]'
    num_opts: '0'
    options: '[1000000, 2000000]'
    type: real
    value: '1000000'
  states: {}
- name: delay_h
  id: variable_qtgui_range
  parameters:
    gui_hint: (4,0,1,1)
    label: Delay (µs)
    rangeType: int
    start: '0'
    step: '1'
    stop: int(800 * samp_rate * 1e-6)
    value: int(160 * samp_rate * 1e-6)
    widget: eng_slider
  states: {}
- name: delay_l
  id: variable_qtgui_range
  parameters:
    gui_hint: (4,1,1,1)
    label: Delay (µs)
    rangeType: int
    start: '0'
    step: '1'
    stop: int(800 * samp_rate * 1e-6)
    value: '0'
    widget: eng_slider
  states: {}
- name: label_802154
  id: variable_qtgui_label
  parameters:
    gui_hint: (1,0,1,1)
    label: <font size='5'><b>IEEE 802.15.4</b> (stronger signal) </font>
    type: string
    value: ''
  states: {}
- name: label_802154_tx_rate
  id: variable_qtgui_label
  parameters:
    gui_hint: (2,0,1,1)
    label: 'Transmission Rate: '
    type: string
    value: 250 kbit/s
  states: {}
- name: label_ble
  id: variable_qtgui_label
  parameters:
    gui_hint: (1,1,1,1)
    label: <font size='5'><b>BLE</b> (weaker signal) </font>
    type: string
    value: ''
  states: {}
- name: pause_button
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: (0,1,1,1)
    initPressed: 'False'
    label: Pause Periodic Transmission
    pressBackgroundColor: red
    pressed: '1'
    relBackgroundColor: red
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: payload_length_h
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,0,1,1)
    label: Payload Length (bytes)
    rangeType: int
    start: '1'
    step: '1'
    stop: '255'
    value: '60'
    widget: eng_slider
  states: {}
- name: payload_length_l
  id: variable_qtgui_range
  parameters:
    gui_hint: (3,1,1,1)
    label: Payload Length (bytes)
    rangeType: int
    start: '1'
    step: '1'
    stop: '255'
    value: '140'
    widget: eng_slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_l
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_h
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude_h
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude_l
    type: complex
  states: {}
- name: blocks_throttle2_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/20
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: 9e3
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0.1'
    seed: '0'
    taps: '1.0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (14,0,8,2)
    size: int(samp_rate/100)
    srate: samp_rate
    tr_delay: 800 * 1e-6
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"trigger"'
    type: complex
    update_time: '0.01'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    gui_hint: (6,0,8,2)
    int_max: '-50'
    int_min: '-60'
    type: complex
    update_time: '0.01'
    wintype: window.WIN_HANN
  states: {}
- name: sic_ble_packet_source_0
  id: sic_ble_packet_source
  parameters:
    base_address: '0x12345678'
    payload_length: payload_length_h
    sample_rate: 10e6
    transmission_rate: ble_transmission_rate
  states: {}
- name: sic_ble_packet_source_0_0
  id: sic_ble_packet_source
  parameters:
    base_address: '0x12345678'
    payload_length: payload_length_l
    sample_rate: 10e6
    transmission_rate: ble_transmission_rate
  states: {}
- name: sic_periodic_message_source_0
  id: sic_periodic_message_source
  parameters:
    message: gr.pmt.mp("trigger")
    n_messages: '-1'
    period_ms: '1000'
  states: {}
- name: sic_transmission_enabler_0
  id: sic_transmission_enabler
  parameters:
    block_size: '1024'
  states: {}
- name: tx_trigger_button
  id: variable_qtgui_msg_push_button
  parameters:
    gui_hint: (0,0,1,1)
    label: Trigger Transmission
    msgName: pressed
    relBackgroundColor: green
    type: int
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: high
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: low
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: high
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: low
  states: {}

connections:
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_throttle2_0_1, '0', sic_ble_packet_source_0, '0']
- [blocks_throttle2_0_1, '0', sic_ble_packet_source_0_0, '0']
- [channels_channel_model_0, '0', blocks_delay_0_0, '0']
- [channels_channel_model_0_0, '0', blocks_delay_0, '0']
- [pause_button, state, sic_periodic_message_source_0, pause]
- [sic_ble_packet_source_0, '0', virtual_sink_0, '0']
- [sic_ble_packet_source_0_0, '0', virtual_sink_1, '0']
- [sic_periodic_message_source_0, out, sic_transmission_enabler_0, trigger]
- [sic_transmission_enabler_0, '0', blocks_throttle2_0_1, '0']
- [tx_trigger_button, pressed, sic_transmission_enabler_0, trigger]
- [virtual_source_0, '0', channels_channel_model_0, '0']
- [virtual_source_1, '0', channels_channel_model_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
