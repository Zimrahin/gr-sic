options:
  parameters:
    author: Diego Badillo-San-Juan
    generate_options: qt_gui
    id: sic_rx_test
    output_language: python
    title: sic_rx_test
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: plot_N
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(10e6)
  states: {}
- name: samples_per_chip
  id: variable
  parameters:
    value: '5'
  states: {}
- name: trigger_delay
  id: variable
  parameters:
    value: '500E-6'
  states: {}
- name: tuning_LPF_cutoff_kHz
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,0
    start: '1000'
    step: '1'
    stop: '5000'
    value: '2000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.025'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation)/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: ble_ieee802154_packet_sink_0
  id: ble_ieee802154_packet_sink
  parameters:
    block_id: '0'
    crc_included: 'True'
    preamble_threshold: '7'
  states: {}
- name: ble_plot_sic_results_0
  id: ble_plot_sic_results
  parameters:
    max_queue_size: '10'
    sample_rate: samp_rate
  states: {}
- name: ble_tag_aligner_0
  id: ble_tag_aligner
  parameters:
    sps: samples_per_chip
    type_high: complex
  states: {}
- name: ble_tagged_iq_to_vector_0
  id: ble_tagged_iq_to_vector
  parameters:
    max_gap: 128*8*8*samples_per_chip
    post_offset: int(trigger_delay * samp_rate)
    pre_offset: int(trigger_delay * samp_rate)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/diego/Documents/GNU_radio_OOT_modules/gr-sic/examples/data/BLE_802154_0dBm_8dBm_0MHz.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/100/2
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 0.045/10
    max_dev: '0'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: samples_per_chip / decimation
    ted_gain: '1.0'
    ted_type: digital.TED_MOD_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: tuning_LPF_cutoff_kHz*1000
    decim: decimation
    gain: '1'
    interp: '100'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate/50
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Testing Tag IQ Stream block"'
    size: plot_N
    srate: samp_rate
    tr_delay: trigger_delay
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Payload start"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 16,0
    label1: '"Quad Demodded"'
    label2: '"Sliced"'
    marker2: '0'
    name: '"Synced and downsampled"'
    nconnections: '2'
    size: int( plot_N/ samples_per_chip)
    srate: int(samp_rate / samples_per_chip)
    tr_chan: '1'
    tr_delay: trigger_delay
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Payload start"'
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '2048'
    type: complex
  states: {state: disabled}
- name: sic_successive_interference_cancellation_0
  id: sic_successive_interference_cancellation
  parameters:
    ble_transmission_rate: 1e6
    frequency_fine_window: '50'
    frequency_start: '25000'
    frequency_step_coarse: '50'
    frequency_step_fine: '1'
    frequency_stop: '30000'
    ieee802154_transmission_rate: 2e6
    max_queue_size: '10'
    protocol_high: '1'
    protocol_low: '0'
    sample_rate: samp_rate
    upsampling_factor: '2'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '160E-6'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', blocks_sub_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', single_pole_iir_filter_xx_0, '0']
- [ble_ieee802154_packet_sink_0, '0', ble_tag_aligner_0, '1']
- [ble_ieee802154_packet_sink_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [ble_ieee802154_packet_sink_0, pdu, blocks_message_debug_1, print]
- [ble_ieee802154_packet_sink_0, pdu, sic_successive_interference_cancellation_0, pdu]
- [ble_tag_aligner_0, '0', ble_tagged_iq_to_vector_0, '0']
- [ble_tag_aligner_0, '0', qtgui_time_sink_x_0, '0']
- [ble_tagged_iq_to_vector_0, out, sic_successive_interference_cancellation_0, iq]
- [blocks_add_xx_0, '0', ble_tag_aligner_0, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_sub_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_1, '1']
- [digital_symbol_sync_xx_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [sic_successive_interference_cancellation_0, out, ble_plot_sic_results_0, in]
- [single_pole_iir_filter_xx_0, '0', blocks_sub_xx_0, '1']
- [virtual_source_0, '0', ble_ieee802154_packet_sink_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-843-g6b25c171
